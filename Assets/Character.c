/* GIMP RGB C-Source image dump 1-byte-run-length-encoded (Character.c) */

#define GIMP_IMAGE_RUN_LENGTH_DECODE(image_buf, rle_data, size, bpp) do \
{ guint __bpp; guint8 *__ip; const guint8 *__il, *__rd; \
  __bpp = (bpp); __ip = (image_buf); __il = __ip + (size) * __bpp; \
  __rd = (rle_data); if (__bpp > 3) { /* RGBA */ \
    while (__ip < __il) { guint __l = *(__rd++); \
      if (__l & 128) { __l = __l - 128; \
        do { memcpy (__ip, __rd, 4); __ip += 4; } while (--__l); __rd += 4; \
      } else { __l *= 4; memcpy (__ip, __rd, __l); \
               __ip += __l; __rd += __l; } } \
  } else if (__bpp == 3) { /* RGB */ \
    while (__ip < __il) { guint __l = *(__rd++); \
      if (__l & 128) { __l = __l - 128; \
        do { memcpy (__ip, __rd, 3); __ip += 3; } while (--__l); __rd += 3; \
      } else { __l *= 3; memcpy (__ip, __rd, __l); \
               __ip += __l; __rd += __l; } } \
  } else { /* RGB16 */ \
    while (__ip < __il) { guint __l = *(__rd++); \
      if (__l & 128) { __l = __l - 128; \
        do { memcpy (__ip, __rd, 2); __ip += 2; } while (--__l); __rd += 2; \
      } else { __l *= 2; memcpy (__ip, __rd, __l); \
               __ip += __l; __rd += __l; } } \
  } } while (0)
static const struct {
  guint  	 width;
  guint  	 height;
  guint  	 bytes_per_pixel; /* 2:RGB16, 3:RGB, 4:RGBA */ 
  guint8 	 rle_pixel_data[210 + 1];
} gimp_image = {
  16, 16, 3,
  "\226\377\377\377\001\000\000\000\203\377\377\377\001\000\000\000\212\377\377\377\207\000\000"
  "\000\210\377\377\377\001\000\000\000\207\377\377\377\001\000\000\000\206\377\377\377\001\000\000"
  "\000\203\377\377\377\003\000\000\000\377\377\377\000\000\000\203\377\377\377\001\000\000\000\205"
  "\377\377\377\001\000\000\000\211\377\377\377\001\000\000\000\205\377\377\377\001\000\000\000\202"
  "\377\377\377\001\000\000\000\203\377\377\377\001\000\000\000\202\377\377\377\001\000\000\000\205"
  "\377\377\377\001\000\000\000\203\377\377\377\203\000\000\000\203\377\377\377\001\000\000\000\206"
  "\377\377\377\001\000\000\000\207\377\377\377\001\000\000\000\210\377\377\377\207\000\000\000\210"
  "\377\377\377\211\000\000\000\206\377\377\377\213\000\000\000\204\377\377\377\215\000\000"
  "\000\203\377\377\377\001\000\000\000\213\377\377\377\001\000\000\000\241\377\377\377",
};

